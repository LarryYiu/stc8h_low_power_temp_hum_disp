# Keil uVision project stc8h_lp.uvproj, settings and files
target stc8h_lp (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: stc8h_lp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\DRIVER;.\LIB;.\STC8H_LIB
  group APP
    ./: STARTUP.A51
    ./APP/: main.c AppSetup.c TimerISR.c
  group LIB
    ./LIB/: GPIO.c UART.c Timer.c ExtInt.c Misc.c ADC.c RTC.c
  group STC8H_LIB
    ./STC8H_LIB/: STC8G_H_GPIO.c STC8G_H_Delay.c STC8G_H_UART.c STC8G_H_Timer.c STC8H_RTC.c STC8G_H_Switch.h STC8G_H_NVIC.c STC8G_H_Exti.c STC8G_H_ADC.c
  group DRIVER
    ./DRIVER/: LCD_Seg.c TouchKey.c KeyExt.c NTC.c HR202L.c Bat.c
